# Keil uVision project LoggerCar.uvprojx, settings and files
target LoggerCar (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F105VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: LoggerCar
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F105xC
  c misc: --C99
  c include: ../Inc;                                         ../Drivers/STM32F1xx_HAL_Driver/Inc;                                         ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                                         ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                                         ../Drivers/CMSIS/Include;                                         ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;                                         ../Middlewares/Third_Party/FreeRTOS/Source/include;                                         ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                                         ..\Task\Inc;                                         ..\Hardware\Inc;                       ../Middlewares/Third_Party/FatFs/src
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/MDK-ARM
    ./: startup_stm32f105xc.s
  group Application/User
    ../Src/: stm32f1xx_hal_msp.c gpio.c stm32f1xx_it.c main.c freertos.c usart.c rtc.c stm32f1xx_hal_timebase_TIM.c adc.c dma.c i2c.c spi.c fatfs.c user_diskio.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_flash_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_pwr.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_flash.c stm32f1xx_hal_tim.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_i2c.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: timers.c event_groups.c list.c queue.c tasks.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Task
    ../Task/Src/: led.c RealTime.c GPRSProcess.c MainProcess.c TFTLCDProcess.c
  group Hardware
    ../Hardware/Src/: common.c rt.c analog.c exFlash.c gprs.c hih5030.c ntc.c input.c gps.c file.c tftlcd.c print.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff.c diskio.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
software components: CMSIS:CORE 4.1.0
